# Keil uVision project display.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: display
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./user/: Font_6x8.c Font_12x16.c gl.c lcd.c Main.c text.c 1986be91_port.h 1986be91_power.h 1986be91_rst_clk.h font_defs.h gl.h lcd.h text.h types.h cm3_macro.h systick.h systick.c
software components: Device:Startup_MDR1986BE9x 1.3.0, Drivers:PORT 1.3.0, Drivers:RST_CLK 1.3.0
